# pytest-runner is only needed for running tests, not for building/installing
DEPENDS:remove = "python3-pytest-runner-native"
